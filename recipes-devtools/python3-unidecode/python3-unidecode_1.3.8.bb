SUMMARY = "ASCII transliterations of Unicode text"
HOMEPAGE = "https://github.com/avian2/unidecode"
LICENSE = "GPL-2.0-or-later"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRC_URI[sha256sum] = "cd7933333390c40608034b22b28c3cc268393c3166d3a82449080766487e387c"

inherit pypi setuptools3
