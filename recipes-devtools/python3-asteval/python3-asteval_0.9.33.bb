SUMMARY = "Safe, minimalistic expression evaluator for Python"
HOMEPAGE = "https://github.com/newville/asteval"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=369792440b6e92c286e9273c52865463"

SRC_URI[sha256sum] = "c656d0d268291580f124c65365511394a1239994c651944516314c114519941a"

inherit pypi setuptools3
