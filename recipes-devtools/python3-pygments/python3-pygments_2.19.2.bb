require python3-pygments.inc
