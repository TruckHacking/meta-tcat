SUMMARY = "Pygments is a generic syntax highlighter for general use in all kinds of software such as forum systems, wikis or other applications that need to prettify source code."
HOMEPAGE = "http://pygments.org/"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f3303d36005697f26f63f53835e05459"

SRC_URI[sha256sum] = "7869f35033333333333333333333333333333333333333333333333333333333"

inherit pypi setuptools3
