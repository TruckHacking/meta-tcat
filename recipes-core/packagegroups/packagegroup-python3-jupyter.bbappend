RDEPENDS:${PN}:remove = "${PYTHON_PN}-nbclassic"
RDEPENDS:${PN}:append = " ${PYTHON_PN}-notebook"
